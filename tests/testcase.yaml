## tests/testcase.yaml
```yaml
tests:
  # section.subsection
  sample.testing.ztest:
    build_only: true
    platform_allow: 
      - nrf52840dk_nrf52840
    tags: test_framework
```
